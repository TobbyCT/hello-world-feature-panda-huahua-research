## panda-huahua-robot/dev/panda-servo-demo/sdkconfig.defaults
```kconfig
# 串口 REPL 相关默认值(可按需调整)
CONFIG_ESP_CONSOLE_UART_DEFAULT=y
CONFIG_ESP_TASK_WDT_INIT=n
CONFIG_FREERTOS_HZ=1000
```
